require gcc-target.inc
