require gcc-runtime.inc
